<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ds18b20_deneme.ewp</path>
  </project>
  <batchBuild />
</workspace>
